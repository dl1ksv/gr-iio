options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: PlutoRx
    output_language: python
    title: PlutoTest
  states: {}

blocks:
- name: fm_station
  id: variable_qtgui_range
  parameters:
    label: RadioStation
    min_len: '400'
    rangeType: int
    start: '88000000'
    step: '1000'
    stop: '150000000'
    value: '94300000'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2200000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '8'
    quad_rate: '384000'
  states: {}
- name: audio_device
  id: parameter
  parameters:
    label: Audio device
    type: str
    value: '"hw:1,0"'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: audio_device
    samp_rate: '48000'
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: Decimation
    type: intx
    value: '1'
  states: {}
- name: fm_station
  id: parameter
  parameters:
    label: FM station
    type: intx
    value: '94300000'
  states: {state: disabled}
- name: hostname
  id: parameter
  parameters:
    label: Hostname
    type: str
    value: '''tuxmobil'''
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: fm_station
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: samp_rate
    uri: pluto.local
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: fm_station
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    uri: uri
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '44100'
    decim: int(samp_rate / (384000 * decimation))
    gain: '1'
    samp_rate: samp_rate / decimation
    type: fir_filter_ccf
    width: '44100'
    win: firdes.WIN_HAMMING
  states: {}
- name: pluto_source_0
  id: pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '0x20000'
    decimation: '1'
    filter: ''
    frequency: fm_station
    gain: '"manual"'
    manual_gain: '64.0'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    uri: ''
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fm_station
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uri
  id: parameter
  parameters:
    label: URI
    type: str
    value: '''ip:pluto.local'''
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [iio_fmcomms2_source_0, '0', low_pass_filter_0, '0']
- [iio_fmcomms2_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [pluto_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
